# Repository test-gh-syncer2/Soldered-Obstacle-sensor-with-easyC-hardware-design

## KiCad design CAD/V1.1.1/Obstacle_sensor_easyC.kicad_pcb

Parts:
C1, C2: 0.1uF; 0603C
D1: purple; 0402LED
FD1: FIDUCIAL; FIDUCIAL_23
H1, H2: HOLE_3.2mm
K1, K3: easyC-SMD; easyC-connector
K2: HEADER-UPDI
K4: DSHP03TS-S
R1: 300R; 0603R
R2, R4, R5: 10k; 0603R
R3: 2k2; 0402R
U1: tcrt5000L; TCRT5000L
U2: ATTINY404-SSNR; SOIC-14

Connections:
3V3: C2.1, K1.3 (3V3), K2.1 (VCC), K3.3 (3V3), R1.2, R2.2, R4.2, R5.2, U2.1 (VDD)
A0: C1.2, R2.1, U1.Coll, U2.3 (PA5)
ADD1: K4.1, U2.7 (PB2)
ADD2: K4.3, U2.6 (PB3)
ADD3: K4.5, U2.5 (PA7)
D0: R3.1, U2.2 (PA4)
GND: C1.1, C2.2, D1.2 (K), K1.4 (GND), K1.5 (SHIELD), K2.3 (GND), K3.4 (GND), K3.5 (SHIELD), K4.2, K4.4, K4.6, U1.Cath, U1.E, U2.14 (GND)
unnamed: D1.1 (A), R3.2
unnamed: R1.1, U1.A
SCL: K1.1 (SCL), K3.1 (SCL), R5.1, U2.9 (PB0)
SDA: K1.2 (SDA), K3.2 (SDA), R4.1, U2.8 (PB1)
UPDI: K2.2 (UPDI), U2.10 (UPDI)

Notes on the sheet:
Obstacle sensor TCRT5000
ATTINY404 easyC MICROCONTROLLER

Board: 2 copper layers, 38.0 x 22.0 mm, 17 parts (2 on the bottom side), 12 nets.

## KiCad design CAD/V1.0.0/Obstacle_sensor_easyC.kicad_pcb

Parts:
C1, C2, C3: 0.1uF; 0603C
D1: purple; 0402LED
FD1: Fiducial_Stencil; FIDUCIAL_1MM_PASTE
H1, H2: HOLE_3.2mm
K1, K3: easyC-SMD; easyC-connector
K2: HEADER-UPDI
K4: DSHP03TS-S
R1: tc33x-2-103e
R2: 1k; 0603R
R3, R4, R6, R7: 10k; 0603R
R5: 1k; 0402R
U1: tcrt5000L; TCRT5000L
U2: LM393; SOIC−8
U3: ATTINY404-SSNR; SOIC-14

Connections:
3V3: C2.2, C3.1, K1.3 (3V3), K2.1 (VCC), K3.3 (3V3), R1.1, R2.2, R3.2, R4.2, R6.2, R7.2, U2.8 (VCC), U3.1 (VDD)
A0: C1.2, R3.1, U1.Coll, U2.3 (1_IN+), U3.3 (PA5)
ADD1: K4.1, U3.7 (PB2)
ADD2: K4.3, U3.6 (PB3)
ADD3: K4.5, U3.5 (PA7)
D0: R4.1, R5.1, U2.1 (1_OUT), U3.2 (PA4)
GND: C1.1, C2.1, C3.2, D1.2 (K), K1.4 (GND), K1.5 (SHIELD), K2.3 (GND), K3.4 (GND), K3.5 (SHIELD), K4.2, K4.4, K4.6, R1.3, U1.Cath, U1.E, U2.4 (GND), U3.14 (GND)
unnamed: D1.1 (A), R5.2
unnamed: R2.1, U1.A
POT: R1.2, U2.2 (1_IN-)
SCL: K1.1 (SCL), K3.1 (SCL), R7.1, U3.9 (PB0)
SDA: K1.2 (SDA), K3.2 (SDA), R6.1, U3.8 (PB1)
UPDI: K2.2 (UPDI), U3.10 (UPDI)

Notes on the sheet:
Obstacle sensor TCRT5000 & LM393
ATTINY404 easyC MICROCONTROLLER

Board: 2 copper layers, 38.0 x 22.0 mm, 21 parts (2 on the bottom side), 13 nets.

## Commit log

2021-09-23 Syncing to git
2021-09-23 Updating open source files.
